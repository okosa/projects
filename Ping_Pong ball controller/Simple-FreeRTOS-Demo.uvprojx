# Keil uVision project Simple-FreeRTOS-Demo.uvprojx, settings and files
target Simple-FreeRTOS-Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Simple-FreeRTOS-Demo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .;.\FreeRTOS-Source\include;.\FreeRTOS-Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Startup
    ./: startup_MPS_CM3.s
  group Demo-files
    ./: main.c FreeRTOSConfig.h CLI.c CLI.h serial.c serial.h registers.c registers.h util.h a2d.c a2d.h PWM.c PWM.h ledio.c ledIO.h
  group FreeRTOS-Source
    ./FreeRTOS-Source/: tasks.c list.c queue.c
    ./FreeRTOS-Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS-Source/portable/MemMang/: heap_1.c
software components: CMSIS:CORE 5.2.0
